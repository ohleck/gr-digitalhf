<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>thread_safe_setters</key><value>1</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>CCSDS_27</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>30*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[109,79]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>4932</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>(3,0,1,2)</value></param>
<param><key>label</key><value>frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>stop</key><value>30e3</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>mode</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>(4,0,1,1)</value></param>
<param><key>label0</key><value>BPSK</value></param>
<param><key>label1</key><value>QPSK</value></param>
<param><key>label2</key><value>8PSK</value></param>
<param><key>label</key><value>mode</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>'0'</value></param>
<param><key>option1</key><value>'1'</value></param>
<param><key>option2</key><value>'2'</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>mu</value></param>
<param><key>value</key><value>0.0035</value></param>
<param><key>gui_hint</key><value>(3,0,1,2)</value></param>
<param><key>label</key><value>mu</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0001</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>stop</key><value>0.01</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nB</value></param>
<param><key>value</key><value>9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nF</value></param>
<param><key>value</key><value>9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nW</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>12001</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable_dummy_decoder_def</key>
<param><key>id</key><value>variable_dummy_decoder_def_0</value></param>
<param><key>framebits</key><value>2048</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-1</value></param>
<param><key>gain</key><value>5</value></param>
<param><key>max_gain</key><value>8</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/Users/chm/Software/gr-digitalhf/examples/bits.bin</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/Users/chm/Software/gr-digitalhf/examples/soft_dec_test.bin</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>(1+(nB+nF)*sps)</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/Users/chm/Software/gr-digitalhf/examples/on5kq.ddns.net_2019-03-20T12_49_38Z_2381.40_iq.wav</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>digitalhf_physical_layer_driver</key>
<param><key>id</key><value>digitalhf_physical_layer_driver_0</value></param>
<param><key>description_name</key><value>STANAG_4285</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>alpha</key><value>0.0005</value></param>
<param><key>mode</key><value>mode</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>nB</key><value>nB</value></param>
<param><key>nF</key><value>nF</value></param>
<param><key>nW</key><value>nW</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>fec_decode_ccsds_27_fb</key>
<param><key>id</key><value>fec_decode_ccsds_27_fb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0</value></param>
<param><key>decoder_list</key><value>CCSDS_27</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>threadtype</key><value>capillary</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>(2,2,3,2)</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>alpha1</key><value>1</value></param>
<param><key>label1</key><value>descrambled symbols</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>(2,0,1,2)</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>preamble cross-correlation</value></param>
<param><key>size</key><value>80*sps</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>0.007</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"time_est"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>.1</value></param>
<param><key>ylabel</key><value>preamble correlation</value></param>
<param><key>ymax</key><value>300</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>gui_hint</key><value>(5,0,1,4)</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate/sps/2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"packet_len"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>soft_dec</value></param>
<param><key>ymax</key><value>7</value></param>
<param><key>ymin</key><value>-7</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024*4</value></param>
<param><key>gui_hint</key><value>(0,0,2,4)</value></param>
<param><key>int_min</key><value>-80</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>fec_decode_ccsds_27_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>fec_extended_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>digitalhf_physical_layer_driver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digitalhf_physical_layer_driver_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitalhf_physical_layer_driver_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digitalhf_physical_layer_driver_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>soft_dec</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>digitalhf_physical_layer_driver_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_decode_ccsds_27_fb_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_decode_ccsds_27_fb_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
